<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>electrosense_final</value></param>
<param><key>author</key><value>Sreeraj Rajendran</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Electrosense sensor code</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>title</key><value>Electosense</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>alpha</value></param>
<param><key>value</key><value>0.75</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cfreq</value></param>
<param><key>value</key><value>scanning.step(start_f,end_f,samp_rate/1.5,prober,hop_mode,0.8,0.8)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>value</key><value>4096</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hop_mode</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>navg_vectors</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ppm</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>prober</value></param>
<param><key>block_id</key><value>vecprobe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>1</value></param>
<param><key>poll_rate</key><value>1/(tune_delay+(1/samp_rate*fft_size*navg_vectors))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rfgain</value></param>
<param><key>value</key><value>40</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>5e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sensorid</value></param>
<param><key>value</key><value>123456</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tune_delay</value></param>
<param><key>value</key><value>20e-3</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>n</key><value>navg_vectors</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_size</value></param>
</block>
<block>
<key>electrosense_discard_samples</key>
<param><key>id</key><value>electrosense_discard_samples_0</value></param>
<param><key>mode</key><value>varchange</value></param>
<param><key>nsamples</key><value>int(tune_delay * samp_rate)</value></param>
<param><key>tag_name</key><value>pmt.intern("burst_len")</value></param>
<param><key>var</key><value>int(cfreq)</value></param>
</block>
<block>
<key>electrosense_mqtt_client</key>
<param><key>id</key><value>electrosense_mqtt_client_0</value></param>
<param><key>ca_cert</key><value></value></param>
<param><key>channel</key><value>electrosense</value></param>
<param><key>certfile</key><value></value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>port</key><value>1883</value></param>
<param><key>keyfile</key><value></value></param>
<param><key>server</key><value>127.0.0.1</value></param>
</block>
<block>
<key>electrosense_sensor_sink</key>
<param><key>id</key><value>electrosense_sensor_sink_0</value></param>
<param><key>avgfactor</key><value>int(3/alpha)</value></param>
<param><key>freq</key><value>int(cfreq)</value></param>
<param><key>certfile</key><value>/home/rsreeraj/gnu_work/gr-electrosense/python/sensor_cert/Sensor-SSL-Cert.pem</value></param>
<param><key>fftsize</key><value>fft_size</value></param>
<param><key>window</key><value>2</value></param>
<param><key>freqoverlap</key><value>0.1</value></param>
<param><key>freqresol</key><value>int(samp_rate/fft_size)</value></param>
<param><key>gain</key><value>rfgain</value></param>
<param><key>hopping</key><value>0</value></param>
<param><key>dtype</key><value>float</value></param>
<param><key>keyfile</key><value>/home/rsreeraj/gnu_work/gr-electrosense/python/sensor_cert/Sensor-SSL-SK.pem</value></param>
<param><key>port</key><value>5000</value></param>
<param><key>avrofile</key><value>/home/rsreeraj/gnu_work/gr-electrosense/python/rtl-spec.avsc</value></param>
<param><key>senid</key><value>sensorid</value></param>
<param><key>server</key><value>collector.electrosense.org</value></param>
<param><key>veclen</key><value>fft_size</value></param>
</block>
<block>
<key>electrosense_variable_updater</key>
<param><key>id</key><value>electrosense_variable_updater_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>end_f</value></param>
<param><key>label</key><value>End Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2000e6</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(fft_size)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import pmt</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>corr0</key><value>ppm</value></param>
<param><key>freq0</key><value>cfreq</value></param>
<param><key>gain_mode0</key><value>True</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>rfgain</value></param>
<param><key>args</key><value></value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>scanning</value></param>
<param><key>source_code</key><value># this module will be imported in the into your flowgraph
cur=-1.0
fft_arr={}
sim_arr={}
sim_red = 1.05

import numpy as np
import random

def crosscorr(x,y):
    a = np.correlate(x, y, mode='full')
    norm = np.sqrt(np.power(x,2).sum()) *  np.sqrt(np.power(y,2).sum())
    #a = (a - np.mean(a)) / (np.std(a) * len(a))
    #return np.nan_to_num(a)
    return np.nan_to_num(a/norm)

def sim2prob(x):
    return np.exp(x)/np.exp(x).sum()

def upd_sim_arr():
    vals = np.array(sim_arr.values())
    keys = np.array(sim_arr.keys())
    prob = sim2prob(vals)
    prob = prob &gt;= np.random.rand()
    vals[prob]=vals[prob]/sim_red
    for i in range(len(keys)):
        sim_arr[keys[i]] = vals[i]
    return min(sim_arr, key=sim_arr.get)

def step(start,end,incr,val,mode,wt,alpha_s):
    global cur
    global fft_arr, sim_arr

    #sequential scanning
    if mode==0:
        cur=cur+incr
    #random scanning
    elif mode == 1:
        rval = int(((end-start)/incr)+0.5)
        cur=cur+incr*random.randint(1,rval)
    #similarity scanning
    else:
        if(fft_arr.has_key(cur)):
            cc = crosscorr(fft_arr[cur],val)
            delf = cc.max()
            r = np.argmax(cc)
            #print r, wt, delf
            sim  = r * wt + (1-wt) * delf
            if(sim_arr.has_key(cur)):
                pass
            else:
                sim_arr[cur]=0
            sim_arr[cur] = alpha_s * sim + sim_arr[cur] * (1-alpha_s)
            new=upd_sim_arr()
            #print "new:",new
            #print "sim:",sim_arr
        else:
            if(cur&gt;0):
                sim_arr[cur]=0
            new=cur+incr
        fft_arr[cur]= val
        cur=new

    if (cur &gt; end or cur &lt; start):
        cur = start
    #print cur
    return cur

</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>alpha</key><value>alpha</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>start_f</value></param>
<param><key>label</key><value>Start frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>50e6</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>cfreq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>35</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>addr=192.168.10.2</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>blocks_probe_signal_vx</key>
<param><key>id</key><value>vecprobe</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>electrosense_sensor_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>vecprobe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>electrosense_discard_samples_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>electrosense_mqtt_client_0</source_block_id><sink_block_id>electrosense_variable_updater_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>electrosense_discard_samples_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>electrosense_discard_samples_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
